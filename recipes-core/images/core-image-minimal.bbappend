IMAGE_INSTALL += "imx-kobs \
    bzip2 \
    gzip \
    mtd-utils \
    mtd-utils-ubifs \
    upgradesys"
